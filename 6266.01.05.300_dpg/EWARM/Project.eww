<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\6266.01.05.300_dpg.ewp</path>
  </project>
  <batchBuild />
</workspace>
